/* AES-128 (FIPS-197) and SM4 (GB/T 32907-2016) encryption in software, and
   the CTR mode of sealed block files. Small rather than fast: the desktop
   uses it, and the CH32H417 has the ECDC engine. Table-driven, so not
   hardened against cache-timing side channels (encrypted-blocks.md 9). */
#include <string.h>
#include "ctr.h"

static const uint8_t aes_sbox[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16,
};

static const uint8_t sm4_sbox[256] = {
    0xd6,0x90,0xe9,0xfe,0xcc,0xe1,0x3d,0xb7,0x16,0xb6,0x14,0xc2,0x28,0xfb,0x2c,0x05,
    0x2b,0x67,0x9a,0x76,0x2a,0xbe,0x04,0xc3,0xaa,0x44,0x13,0x26,0x49,0x86,0x06,0x99,
    0x9c,0x42,0x50,0xf4,0x91,0xef,0x98,0x7a,0x33,0x54,0x0b,0x43,0xed,0xcf,0xac,0x62,
    0xe4,0xb3,0x1c,0xa9,0xc9,0x08,0xe8,0x95,0x80,0xdf,0x94,0xfa,0x75,0x8f,0x3f,0xa6,
    0x47,0x07,0xa7,0xfc,0xf3,0x73,0x17,0xba,0x83,0x59,0x3c,0x19,0xe6,0x85,0x4f,0xa8,
    0x68,0x6b,0x81,0xb2,0x71,0x64,0xda,0x8b,0xf8,0xeb,0x0f,0x4b,0x70,0x56,0x9d,0x35,
    0x1e,0x24,0x0e,0x5e,0x63,0x58,0xd1,0xa2,0x25,0x22,0x7c,0x3b,0x01,0x21,0x78,0x87,
    0xd4,0x00,0x46,0x57,0x9f,0xd3,0x27,0x52,0x4c,0x36,0x02,0xe7,0xa0,0xc4,0xc8,0x9e,
    0xea,0xbf,0x8a,0xd2,0x40,0xc7,0x38,0xb5,0xa3,0xf7,0xf2,0xce,0xf9,0x61,0x15,0xa1,
    0xe0,0xae,0x5d,0xa4,0x9b,0x34,0x1a,0x55,0xad,0x93,0x32,0x30,0xf5,0x8c,0xb1,0xe3,
    0x1d,0xf6,0xe2,0x2e,0x82,0x66,0xca,0x60,0xc0,0x29,0x23,0xab,0x0d,0x53,0x4e,0x6f,
    0xd5,0xdb,0x37,0x45,0xde,0xfd,0x8e,0x2f,0x03,0xff,0x6a,0x72,0x6d,0x6c,0x5b,0x51,
    0x8d,0x1b,0xaf,0x92,0xbb,0xdd,0xbc,0x7f,0x11,0xd9,0x5c,0x41,0x1f,0x10,0x5a,0xd8,
    0x0a,0xc1,0x31,0x88,0xa5,0xcd,0x7b,0xbd,0x2d,0x74,0xd0,0x12,0xb8,0xe5,0xb4,0xb0,
    0x89,0x69,0x97,0x4a,0x0c,0x96,0x77,0x7e,0x65,0xb9,0xf1,0x09,0xc5,0x6e,0xc6,0x84,
    0x18,0xf0,0x7d,0xec,0x3a,0xdc,0x4d,0x20,0x79,0xee,0x5f,0x3e,0xd7,0xcb,0x39,0x48,
};

static uint32_t get32(const uint8_t *p) {           /* big-endian */
    return ((uint32_t)p[0] << 24) | ((uint32_t)p[1] << 16) | ((uint32_t)p[2] << 8) | p[3];
}

static void put32(uint8_t *p, uint32_t x) {
    p[0] = (uint8_t)(x >> 24); p[1] = (uint8_t)(x >> 16);
    p[2] = (uint8_t)(x >> 8);  p[3] = (uint8_t)x;
}

static uint32_t rotl(uint32_t x, int n) {
    return (x << n) | (x >> (32 - n));
}

/* AES ---------------------------------------------------------------- */

static uint32_t aes_subword(uint32_t x) {
    return ((uint32_t)aes_sbox[x >> 24] << 24) | ((uint32_t)aes_sbox[(x >> 16) & 255] << 16)
         | ((uint32_t)aes_sbox[(x >> 8) & 255] << 8) | aes_sbox[x & 255];
}

static void aes_setkey(uint32_t rk[44], const uint8_t key[16]) {
    uint8_t rcon = 1;
    for (int i = 0; i < 4; i++) {
        rk[i] = get32(key + 4 * i);
    }
    for (int i = 4; i < 44; i++) {
        uint32_t t = rk[i - 1];
        if (i % 4 == 0) {
            t = aes_subword(rotl(t, 8)) ^ ((uint32_t)rcon << 24);
            rcon = (uint8_t)((rcon << 1) ^ ((rcon & 0x80) ? 0x1b : 0));
        }
        rk[i] = rk[i - 4] ^ t;
    }
}

static uint8_t xtime(uint8_t x) {
    return (uint8_t)((x << 1) ^ ((x & 0x80) ? 0x1b : 0));
}

static void aes_encrypt(const uint32_t rk[44], const uint8_t in[16], uint8_t out[16]) {
    uint8_t s[16], t[16];
    for (int i = 0; i < 4; i++) {
        put32(s + 4 * i, get32(in + 4 * i) ^ rk[i]);
    }
    for (int round = 1; round <= 10; round++) {
        for (int i = 0; i < 16; i++) {          /* SubBytes and ShiftRows */
            t[i] = aes_sbox[s[(i + 4 * (i % 4)) % 16]];
        }
        if (round < 10) {                       /* MixColumns */
            for (int c = 0; c < 4; c++) {
                uint8_t *a = t + 4 * c;
                uint8_t all = a[0] ^ a[1] ^ a[2] ^ a[3], a0 = a[0];
                a[0] ^= all ^ xtime(a[0] ^ a[1]);
                a[1] ^= all ^ xtime(a[1] ^ a[2]);
                a[2] ^= all ^ xtime(a[2] ^ a[3]);
                a[3] ^= all ^ xtime(a[3] ^ a0);
            }
        }
        for (int i = 0; i < 4; i++) {           /* AddRoundKey */
            put32(s + 4 * i, get32(t + 4 * i) ^ rk[4 * round + i]);
        }
    }
    memcpy(out, s, 16);
}

/* SM4 ---------------------------------------------------------------- */

static uint32_t sm4_tau(uint32_t x) {
    return ((uint32_t)sm4_sbox[x >> 24] << 24) | ((uint32_t)sm4_sbox[(x >> 16) & 255] << 16)
         | ((uint32_t)sm4_sbox[(x >> 8) & 255] << 8) | sm4_sbox[x & 255];
}

static void sm4_setkey(uint32_t rk[32], const uint8_t key[16]) {
    static const uint32_t fk[4] = { 0xa3b1bac6, 0x56aa3350, 0x677d9197, 0xb27022dc };
    uint32_t k[4];
    for (int i = 0; i < 4; i++) {
        k[i] = get32(key + 4 * i) ^ fk[i];
    }
    for (int i = 0; i < 32; i++) {
        uint32_t ck = 0;                        /* CK: byte j is (4i + j) * 7 mod 256 */
        for (int j = 0; j < 4; j++) {
            ck = (ck << 8) | (uint8_t)((4 * i + j) * 7);
        }
        uint32_t b = sm4_tau(k[1] ^ k[2] ^ k[3] ^ ck);
        uint32_t next = k[0] ^ b ^ rotl(b, 13) ^ rotl(b, 23);
        k[0] = k[1]; k[1] = k[2]; k[2] = k[3]; k[3] = next;
        rk[i] = next;
    }
}

static void sm4_encrypt(const uint32_t rk[32], const uint8_t in[16], uint8_t out[16]) {
    uint32_t x[4];
    for (int i = 0; i < 4; i++) {
        x[i] = get32(in + 4 * i);
    }
    for (int i = 0; i < 32; i++) {
        uint32_t b = sm4_tau(x[1] ^ x[2] ^ x[3] ^ rk[i]);
        uint32_t next = x[0] ^ b ^ rotl(b, 2) ^ rotl(b, 10) ^ rotl(b, 18) ^ rotl(b, 24);
        x[0] = x[1]; x[1] = x[2]; x[2] = x[3]; x[3] = next;
    }
    for (int i = 0; i < 4; i++) {
        put32(out + 4 * i, x[3 - i]);
    }
}

/* The interface ------------------------------------------------------- */

int ctr_setkey(ctr_key *k, int cipher, const uint8_t key[16]) {
    memset(k, 0, sizeof *k);
    if (cipher == CTR_AES128) {
        aes_setkey(k->rk, key);
    } else if (cipher == CTR_SM4) {
        sm4_setkey(k->rk, key);
    } else {
        return -1;
    }
    k->cipher = cipher;
    return 0;
}

void ctr_encrypt_block(const ctr_key *k, const uint8_t in[16], uint8_t out[16]) {
    if (k->cipher == CTR_SM4) {
        sm4_encrypt(k->rk, in, out);
    } else {
        aes_encrypt(k->rk, in, out);
    }
}

void ctr_crypt_block(const ctr_key *k, const uint8_t nonce[8], uint32_t n,
                     uint8_t *buf, size_t len) {
    uint8_t ctr[16], ks[16];
    uint64_t count = (uint64_t)n * 256;
    memcpy(ctr, nonce, 8);
    for (size_t at = 0; at < len; at += 16, count++) {
        for (int i = 0; i < 8; i++) {
            ctr[8 + i] = (uint8_t)(count >> (56 - 8 * i));
        }
        ctr_encrypt_block(k, ctr, ks);
        size_t m = len - at < 16 ? len - at : 16;
        for (size_t i = 0; i < m; i++) {
            buf[at + i] ^= ks[i];
        }
    }
    memset(ks, 0, sizeof ks);
}

void ctr_wipe(ctr_key *k) {
    volatile uint8_t *p = (volatile uint8_t *)k;
    for (size_t i = 0; i < sizeof *k; i++) {
        p[i] = 0;
    }
}
